Commit message: Made google objects a bit heavier

File: docker_volume/environments/assets/google/object-template.urdf (robot description, URDF)
Before this commit: robot object.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 1e-1 -> 1.5e-1
